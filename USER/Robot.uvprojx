# Keil uVision project Robot.uvprojx, settings and files
target Robot (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Robot +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\FWLIB\inc;..\USER;..\SYSTEM\sys;..\SYSTEM\delay;..\HARDWARE\pwm;..\HARDWARE\led;..\HARDWARE\usart;..\HARDWARE\servo;..\HARDWARE\usart_vs;..\HARDWARE\trigono;..\HARDWARE\mainsubf
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group HARDWARE
    ../HARDWARE/pwm/: pwm.c
    ../HARDWARE/led/: led.c
    ../HARDWARE/usart/: usart.c
    ../HARDWARE/servo/: servo.c
    ../HARDWARE/usart_vs/: usart_vs.c
    ../HARDWARE/trigono/: trigono.c
    ../HARDWARE/mainsubf/: mainsubf.c
